# Keil uVision project tp.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: S32K144HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tp
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm include: .\RTE\Device\S32K144HAxxxLHx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLHx\S32K144_64_flash.sct
  group Source Group 1
    ./: clocks_and_modes.c clocks_and_modes.h LPUART.h tp.c LPUART.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.0
